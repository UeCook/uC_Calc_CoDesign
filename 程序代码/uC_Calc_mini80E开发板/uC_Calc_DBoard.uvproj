# Keil uVision project uC_Calc_DBoard.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051 Core CAST, Inc.
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: uC_Calc_DBoard +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 uC_Calc_DBoard.c
